<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Electricity_Meter_Uni.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>ALL</name>
            <member>
                <project>Electricity_Meter_Uni</project>
                <configuration>Electricity_Meter_Uni_EndDevice</configuration>
            </member>
            <member>
                <project>Electricity_Meter_Uni</project>
                <configuration>Electricity_Meter_Uni_Router</configuration>
            </member>
            <member>
                <project>Electricity_Meter_Uni</project>
                <configuration>Electricity_Meter_Uni_Router_CC2592</configuration>
            </member>
            <member>
                <project>Electricity_Meter_Uni</project>
                <configuration>Electricity_Meter_Uni_EndDevice_CC2592</configuration>
            </member>
            <member>
                <project>Electricity_Meter_Uni</project>
                <configuration>Electricity_Meter_Uni_EndDevice_CC2591</configuration>
            </member>
            <member>
                <project>Electricity_Meter_Uni</project>
                <configuration>Electricity_Meter_Uni_Router_CC2591</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
